# Keil uVision project GEC_FLY.uvprojx, settings and files
target GEC_FLY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GEC_FLY +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\USER;..\DRIVER;..\CM3;..\LIB\inc;..\PATAMETER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c includes.h
  group DRIVER
    ../DRIVER/: adc_dma.c eeprom.c IOI2C.c Motor.c MPU6050.c NRF24l01.c Spi.c USART.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group PATAMETER
    ../PATAMETER/: controller.c delay.c filter.c func.c imu.c pid.c configer.c motorcontroller.c My_Uart.c wifi.c
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c
    ../CM3/startup/: startup_stm32f10x_md.s
